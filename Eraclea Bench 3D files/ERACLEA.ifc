Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T11:40:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 11:40:37 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{7541E12F-EFF7-43EF-9B05-335E1BDAC181}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 11:40:35 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 11:40:35 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 11:40:35 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAPP015 - GRANITO, Panca ERACLEA:0PAPP015 - GRANITO:138183
In: 0 - Piano Terra
Type - Material: GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca ERACLEA
Type - Dati identità - BIM Name: ERACLEA; BIM Object Type: Panchine - Benches; Code: 0PAPP015; Designer: BELLITALIA DESIGN; Family Name: ERACLEA; Nome del tipo: 0PAPP015 - GRANITO; URL Eng: https://www.bellitalia.net/en/products/benches/eraclea/; URL Ita: https://www.bellitalia.net/prodotti/panchine/eraclea/
Type - Dimensioni - Dimensions: 2200 mm x 610 mm x 450 mm
Type - Generale - Accessori: 1 striscia LED; Accessories: 1 LED strip; Descrizione Tecnica Famiglia: "Panca lineare monolitica mod. “ERACLEA” con seduta di forma rettangolare. Sezione longitudinale a C permette l'appoggio su due supporti alle estremità contenendone il peso totale."; Descrizione Tecnica per Codice: PANCA ERACLEA IN GRANITO (COLORE A SCELTA) CON SABBIATURA SUPERFICIE DEL SEDILE SPAZZOLATA VERNICE ANTIDECADIMENTO; Fissaggio: Appoggio; Fixings: freestanding; Technical Description Family: "Monolithic linear bench mod. “ERACLEA” with seat rectangular in shape. Longitudinal C-shaped section allows the support to be placed on two supports at the ends, containing the total weight."; Technical Description for Article: ERACLEA BENCH IN GRANITE (COLOR TO BE CHOSEN) SANDBLASTED WITH BRUSHED SEAT SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; MATERIALE SEDUTA: GRANITO; Primary Material: White granite; Secondary Material: Granite stones
Type - Meccanica - Weight ( kg): 595 kg
Pset_BuildingElementProxyCommon - Reference: 0PAPP015 - GRANITO
Altro - Famiglia: Panca ERACLEA: 0PAPP015 - GRANITO; Famiglia e tipo: Panca ERACLEA: 0PAPP015 - GRANITO; ID tipo: Panca ERACLEA: 0PAPP015 - GRANITO; Tipo: Panca ERACLEA: 0PAPP015 - GRANITO
Dimensioni - Area: 2.17882 m2; Volume: 0.249592 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
